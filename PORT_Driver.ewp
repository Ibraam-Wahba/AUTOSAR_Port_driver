# IAR project PORT_Driver.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: Common_Macros.h Port.c Port.h Port_Cfg.h Port_PBcfg.c Port_reg.h Std_Types.h
    ../New floder/: Compiler.h Platform_Types.h
    ../TIVA_C_drivers/AUTOSAR_Project/: Det.c Det.h tm4c123gh6pm_registers.h
